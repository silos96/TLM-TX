options:
  parameters:
    generate_options: qt_gui
    id: TX_RX_PCM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '16'
  states: {}
- name: L
  id: variable
  parameters:
    value: '2'
  states: {}
- name: L0
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: cpm_type
  id: variable
  parameters:
    value: analog.cpm.LRC
  states: {}
- name: cpmmod
  id: variable
  parameters:
    value: digital.cpmmod_bc(cpm_type, h, sampersym, L,  0.3)
  states: {}
- name: data
  id: variable
  parameters:
    value: '[random.getrandbits(1)for i in range(payload_size)]'
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: h/(2*sym_time)
  states: {}
- name: gamma
  id: variable
  parameters:
    value: '1'
  states: {}
- name: h
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '10232'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[1,0,1,0,1,1,0,0,1,1,0,1,1,1,0,1,1,0,1,0,0,1,0,0,1,1,1,0,0,0,1,0,1,1,1,1,0,0,1,0,1,0,0,0,1,1,0,0,0,0,1,0,0,0,0,0,1,1,1,1,1,1,0,0]'
  states: {}
- name: preamble_antipodal
  id: variable
  parameters:
    value: '[1,255,1,255,1,1,255,255,1,1,255,1,1,1,255,1,1,255,1,255,255,1,255,255,1,1,1,255,255,255,1,255,1,1,1,1,255,255,1,255,1,255,255,255,1,1,255,255,255,255,1,255,255,255,255,255,1,1,1,1,1,1,255,255]'
  states: {}
- name: preamble_antipodal_ccsds
  id: variable
  parameters:
    value: '[255,255,255,1,1,255,1,255,1,1,255,255,1,1,1,1,1,1,1,1,1,1,255,255,255,255,255,1,1,1,255,1]'
  states: {}
- name: preamble_ccsds
  id: variable
  parameters:
    value: '[0,0,0,1,1,0,1,0,1,1,0,0,1,1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,0,1]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: sampersym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samprate_sps
  id: variable
  parameters:
    value: samp_rate*sampersym
  states: {}
- name: sym_time
  id: variable
  parameters:
    value: sampersym/samp_rate
  states: {}
- name: sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble_antipodal_ccsds
    mod: cpmmod
    taps: '[1]'
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: my_block_0
    function_name: get_number
    poll_rate: '10'
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-5'
    reference: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*freq_dev)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D+1
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/temis/Desktop/test silino tlm-tx/c0c1/TX_sym_thy
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/temis/Desktop/test silino tlm-tx/c0c1/RX_sym
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: bitstream_out
    type: float
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/temis/Desktop/test silino tlm-tx/c0c1/RX_sym_coarse_freq_agc
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /home/temis/Desktop/test silino tlm-tx/c0c1/RX_sym_coarse_freq_agc_symsync
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: /home/temis/Desktop/test silino tlm-tx/c0c1/RX_sym_coarse_freq_agc_symsync_freqfine
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0_1
  id: blocks_file_sink
  parameters:
    file: /home/temis/Desktop/test silino tlm-tx/c0c1/bitstream_demod
    type: float
  states: {}
- name: blocks_file_sink_0_0_1_0_1_0
  id: blocks_file_sink
  parameters:
    file: /home/temis/Desktop/test silino tlm-tx/c0c1/bitstream_demod_tresh
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("start")
    file: /home/temis/Desktop/bitstream per tx/bitstream_in
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_3
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: L0*sampersym
    max_iter: '400000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(6.28*D*sym_time)*gamma
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tagged_stream_align_0_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: start
    type: float
  states: {}
- name: blocks_tagged_stream_align_0_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: corr_start
    type: float
  states: {}
- name: blocks_tagged_stream_align_0_1_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: corr_start
    type: float
  states: {}
- name: blocks_tagged_stream_align_0_1_0_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: corr_start
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0_1_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: corr_start
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: samp_rate
    sensitivity: '54'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: sampersym
    symbols: sync_word
    threshold: '0.6'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_cpmmod_bc_0_1
  id: digital_cpmmod_bc
  parameters:
    L: L
    beta: '0'
    mod_index: h
    samples_per_symbol: sampersym
    type: analog.cpm.LRC
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '9'
    loop_bw: '0.1'
    max_dev: '1.1'
    osps: sampersym
    resamp_type: digital.IR_MMSE_8TAP
    sps: sampersym
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berlimit: '-10'
    berminerrors: '0'
    test_mode: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sampersym
    taps: '1'
    type: fff
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: '30'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: '2245000000'
    rf_port_select: '''A'''
    samplerate: samprate_sps
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: ip:192.168.3.2
  states: {state: disabled}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: '2245000000'
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '35'
    quadrature: 'True'
    rf_port_select: '''A_N'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samprate_sps
    type: fc32
    uri: ip:192.168.3.2
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    fpass: samprate_sps-1
    frequency: '2245000000'
    fstop: samprate_sps
    samplerate: samprate_sps
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    fpass: samprate_sps-1
    frequency: '2249000000'
    fstop: samprate_sps
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '16'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samprate_sps
    type: fc32
    uri: ip:192.168.241.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samprate_sps/3.5
    decim: '1'
    gain: '1'
    samp_rate: samprate_sps
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,2,1,1
    label1: RX sym
    label2: RX filtered sym
    name: '"PCM/FM rx"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: 760e3
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: mod RX signal
    label2: mod RX signal filtered
    name: '"PCM/FM rx spectrum"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    max: '0'
    min: '-10'
    name: '"BER (comparatore)"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '82112'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    color3: blue
    ctrlpanel: 'True'
    label1: tx (mod)
    label2: rx
    label3: detected rx seq
    name: '"Sequenze NRZ"'
    nconnections: '3'
    size: '10264'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '82112'
    srate: samp_rate
    type: complex
    update_time: '1'
    ymax: '1000'
    ymin: '-1000'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '400'
    ymin: '-400'
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: VCO
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '2'
    ymax: '400'
    ymin: '-400'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: TX signal
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: tx seq BER
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: rx symbol+freq
  states: {}
- name: virtual_sink_0_2_0
  id: virtual_sink
  parameters:
    stream_id: rx symbol
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx seq
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: mod seq
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: RX signal
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: estimated rx seq
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx symbol+freq
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rx seq
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: tx seq BER
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: RX signal
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: rx symbol
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: rx seq
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: mod seq
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: estimated rx seq
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_file_sink_0_0_1, '0']
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0_0, '1']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_const_source_x_1, '0', blocks_sub_xx_1, '1']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_5, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_1, '1']
- [blocks_conjugate_cc_1, '0', blocks_multiply_xx_0, '0']
- [blocks_conjugate_cc_1, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', virtual_sink_0_1, '0']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_1, '0', blocks_multiply_xx_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_float_to_char_0_0, '0', blocks_pack_k_bits_bb_1_0, '0']
- [blocks_float_to_char_1, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_float_to_char_3, '0', digital_cpmmod_bc_0_1, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0_0_1_0_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0_2, '0']
- [blocks_multiply_xx_1, '0', virtual_sink_0_2_0, '0']
- [blocks_pack_k_bits_bb_1, '0', fec_ber_bf_0, '0']
- [blocks_pack_k_bits_bb_1_0, '0', fec_ber_bf_0, '1']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_sub_xx_1, '0', blocks_float_to_char_3, '0']
- [blocks_sub_xx_1, '0', blocks_tagged_stream_align_0_0, '0']
- [blocks_tagged_stream_align_0_0, '0', blocks_delay_0, '0']
- [blocks_tagged_stream_align_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_tagged_stream_align_0_1_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_tagged_stream_align_0_1_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_tagged_stream_align_0_1_1, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', blocks_add_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_1, '0']
- [blocks_threshold_ff_0, '0', blocks_sub_xx_0, '1']
- [blocks_threshold_ff_0_0, '0', blocks_file_sink_0_0_1_0_1_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_vco_c_0, '0', blocks_conjugate_cc_1, '0']
- [channels_channel_model_0, '0', low_pass_filter_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_corr_est_cc_0, '0', blocks_tagged_stream_align_0_1_0_0, '0']
- [digital_corr_est_cc_0, '1', qtgui_time_sink_x_1, '0']
- [digital_cpmmod_bc_0_1, '0', blocks_file_sink_0, '0']
- [digital_cpmmod_bc_0_1, '0', blocks_probe_rate_0_0, '0']
- [digital_cpmmod_bc_0_1, '0', iio_fmcomms2_sink_0, '0']
- [digital_cpmmod_bc_0_1, '0', iio_pluto_sink_0, '0']
- [digital_cpmmod_bc_0_1, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_delay_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_delay_1, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_0_0_1_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_2_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_0_0_1_0_1, '0']
- [fir_filter_xxx_0, '0', virtual_sink_1, '0']
- [iio_fmcomms2_source_0, '0', virtual_sink_3, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0_0, '0']
- [iio_pluto_source_0, '0', blocks_probe_rate_0, '0']
- [iio_pluto_source_0, '0', virtual_sink_3, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [virtual_source_1, '0', digital_corr_est_cc_0, '0']
- [virtual_source_1_0, '0', blocks_tagged_stream_align_0_1, '0']
- [virtual_source_2, '0', blocks_threshold_ff_0_0, '0']
- [virtual_source_3, '0', channels_channel_model_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_3_0, '0', blocks_moving_average_xx_0_1, '0']
- [virtual_source_4, '0', blocks_tagged_stream_align_0_1_1, '0']
- [virtual_source_5, '0', blocks_multiply_xx_0, '1']
- [virtual_source_5_0, '0', blocks_tagged_stream_align_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
